MrT sim-spice
R1 1 3 1e9
R2 3 0 500
R4 1 8 1e9
R5 8 0 500
R6 1 12 1e9
V1 1 0 10V
.op
