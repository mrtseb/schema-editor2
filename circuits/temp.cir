MrT sim-spice
R1 1 0 500
R3 1 7 1e9
R4 7 0 500
R6 1 11 1e9
R7 11 14 1e9
R8 14 0 500
R10 1 21 1e9
R11 1 21 1e9
R12 21 0 500
V1 1 0 10V
.op
