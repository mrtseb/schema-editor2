MrT sim-spice
R1 1 6 1e9
R2 1 8 1
R3 6 0 500
R4 8 0 500
V1 1 0 10V
.op
