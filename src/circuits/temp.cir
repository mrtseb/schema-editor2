MrT sim-spice
R1 1 4 1
R2 4 0 500
R4 1 9 1
R5 9 0 500
V1 1 0 10V
.op
