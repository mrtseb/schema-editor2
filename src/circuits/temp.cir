MrT sim-spice
R1 1 4 1e9
R2 4 0 500
V1 1 0 10V
.op
