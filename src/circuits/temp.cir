MrT sim-spice
R1 1 0 500
R3 1 7 1
R4 7 0 500
R6 1 12 1e9
R7 12 0 500
R9 1 16 1e9
R10 16 19 1e9
R11 19 0 500
R13 1 26 1e9
R14 1 26 1e9
R15 26 0 500
R17 1 30 1
R18 1 32 1e9
R19 30 37 1e9
R20 32 37 1
R21 37 0 500
V1 1 0 10V
.op
